# Keil uVision project Embedded_MIDI_Sequencer.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Embedded_MIDI_Sequencer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\inc;..\src;..\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ../main/: main.c
  group src
    ../src/: buttons.c display7seg.c gpio.c keypad.c lcd.c midi_uart.c sequencer.c timer_seq.c
    C:/Users/Laptop-4TP86M2/Desktop/425 Final Project/embedded-midi-sequencer-main/src/: SysTick_Delay.c
  group inc
    ../inc/: buttons.h display7seg.h gpio.h keypad.h lcd.h midi_uart.h sequencer.h timer_seq.h
    C:/Users/Laptop-4TP86M2/Desktop/425 Final Project/embedded-midi-sequencer-main/inc/: SysTick_Delay.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
